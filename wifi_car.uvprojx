# Keil uVision project wifi_car.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi_car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: .\wifi_car_driver\Inc;.\wifi_car_driver\Src;.\wifi_car_driver\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\wifi_car_driver\Drivers\CMSIS\Include;.\wifi_car_driver\MDK-ARM;.\wifi_car_driver\Drivers\STM32F4xx_HAL_Driver\Inc;.\wifi_car_driver\Drivers\STM32F4xx_HAL_Driver\Src;.\App\Arithmetic;.\App\Navipack_Sdk\api;.\App\Navipack_Sdk\core;.\App\Source;.\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./wifi_car_driver/MDK-ARM/: startup_stm32f446xx.s
  group Drivers/STM32F1xx_HAL_Driver
    ./wifi_car_driver/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Application/User
    ./wifi_car_driver/Src/: adc.c dcmi.c dma.c gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c tim.c usart.c
  group Drivers/CMSIS
    ./wifi_car_driver/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h stm32f4xx.h stm32f446xx.h
  group NavipackSDK
    ./App/Navipack_Sdk/api/: navipack_api.c
    ./App/Navipack_Sdk/core/: navipack_session_layer.c navipack_transport_layer.c
  group Arithmetic
    ./App/Arithmetic/: queue.c c_algorithm.c
  group App
    ./App/Source/: app_main.c app_tim.c app_comm2_wifi.c app_comm1.c
  group Bsp
    ./Bsp/: usart_bsp.c esp8266_bsp.c camera_bsp.c ov9650_bsp.c iic_soft_bsp.c
